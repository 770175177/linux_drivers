## yuanzi/linux/drivers/net/wireless/rtl8192cu/Kconfig
```kconfig
config EXTRA_RTL8192CU
	tristate "extra Realtek 8192C USB WiFi"
	depends on USB
	---help---
	  Help message of EXTRA_RTL8192CU
```
